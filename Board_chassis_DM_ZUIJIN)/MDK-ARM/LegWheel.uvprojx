# Keil uVision project LegWheel.uvprojx, settings and files
target LegWheel (6160000::V6.16::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: LegWheel +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Devices/WS2812;../Bsp/UART;../Devices/IBUS;../Applications;../Devices/Unitree;../Algorithm;../Bsp/DWT;../Algorithm/inc;../Devices/IMU;../Drivers/CMSIS/DSP;../Devices/Saber_C3;../Devices/M1505B;../Bsp/CAN;../Middlewares/ST/ARM/DSP/Inc;../Devices/SBUS;../Devices/M6020;..\Devices\DM8009P;..\Devices\M3508;..\Devices\tpid;..\Devices\VOFA+;..\Bsp\UART;..\Devices\N100
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c gpio.c freertos.c crc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Applications
    ../Applications/: Chassis.cpp Chassis.h Task_manager.cpp Task_manager.h ins.cpp ins.h board_comm.c board_comm.h
  group Algorithm
    ../Algorithm/src/: lqr.cpp vmc.cpp kalman_filter.cpp pid.cpp crc_def.cpp user_lib.cpp
    ../Algorithm/inc/: lqr.h vmc.h kalman_filter.h pid.h crc_def.h user_lib.h
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Devices
    ../Devices/M6020/: M6020_Motor.c M6020_Motor.h
    ../Devices/Saber_C3/: Saber_C3.c Saber_C3.h
    ../Devices/WS2812/: ws2812.c ws2812.h
    ../Devices/DM8009P/: DM_8009P.cpp DM_8009P.h
    ../Devices/M3508/: M3508.c M3508.h
    ../Devices/tpid/: tpid.c tpid.h
    ../Devices/VOFA+/: vofa.c vofa.h
    ../Devices/N100/: N100.c N100.h
    ../Devices/dji_motor/: dji_motor.cpp
    ./: dji_motor.h
  group BSP
    ../Bsp/DWT/: bsp_dwt.c bsp_dwt.h
    ../Bsp/CAN/: BSP_fdcan.c BSP_fdcan.h
    ../Bsp/UART/: bsp_uart.c bsp_uart.h
software components: CMSIS:CORE 6.1.0
